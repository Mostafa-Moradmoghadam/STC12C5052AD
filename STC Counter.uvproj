# Keil uVision project STC Counter.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5205AD STC12C5201AD Series
  cpu: IRAM(0-0xFF) IROM(0-0x13FF) CLOCK(45000000)
  output: STC Counter +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 STC Counter.c TM1637.c MH_OS.c Task.c Task.h
